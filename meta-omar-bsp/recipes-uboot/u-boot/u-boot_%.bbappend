FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://fragment.cfg"

UBOOT_CONFIGFRAGMENTS += "fragment.cfg"

